/* ======================================================================
   网络收音机 V1  ——  ESP32-S3，复用 AI 盒子那套硬件（纯网络版）
   ======================================================================
   板子      ESP32-S3 N16R8（Flash 16M / PSRAM 8M）
   编译参数  esp32:esp32:esp32s3:FlashSize=16M,PSRAM=opi,PartitionScheme=default_8MB
   依赖库    ESP32-audioI2S  **3.0.12**（不是 4.x！4.x 要 C++20，2.0.17 内核编不过）
             Adafruit SSD1306 + Adafruit GFX（+ BusIO，SSD1306 依赖）

   接线（和 AI 盒子一模一样，一根线都不用动）
     SPK MAX98357 : VIN->5V  GND->GND  SD->3.3V  DIN->4  BCLK->5  LRC->6
     OLED SSD1306 : SDA->8   SCL->9    VCC->3.3V GND->GND
     KEYS 4键模块 : 公共端->GND  ^(K1)->13  v(K2)->14  #(K3)->15  *(K4)->16

   按键
     K1 ^  上一个台
     K2 v  下一个台
     K3 #  确定 / 重新连接当前台
     K4 *  紧急暂停（任何状态下立刻静音，再按恢复）

   ★★ 本文件里有家里 WiFi 明文密码，只在本地保存 ★★
      不要推到任何公开仓库。要公开就把 WIFI_LIST 改成占位符。
   ====================================================================== */

#define FW_VER 1

#include <WiFi.h>
#include <WiFiMulti.h>
#include <Wire.h>
#include <Adafruit_GFX.h>
#include <Adafruit_SSD1306.h>
#include <Preferences.h>
#include <WebServer.h>
#include <DNSServer.h>
#include "Audio.h"

/* ---------------- 引脚 ---------------- */
#define PIN_I2S_BCLK   5
#define PIN_I2S_LRC    6
#define PIN_I2S_DOUT   4

#define PIN_SDA        8
#define PIN_SCL        9

#define BTN_PREV      13   /* K1 ^ */
#define BTN_NEXT      14   /* K2 v */
#define BTN_OK        15   /* K3 # */
#define BTN_STOP      16   /* K4 * 紧急暂停 */

/* ---------------- 屏幕 ---------------- */
#define SCR_W 128
#define SCR_H 64
Adafruit_SSD1306 display(SCR_W, SCR_H, &Wire, -1);
bool screenOK = false;

/* ---------------- 音频 ---------------- */
Audio audio;
const uint32_t IN_BUF_TOTAL = 1000UL * 1024UL;   /* setBufsize 的 PSRAM 部分 */

/* ---------------- 电台表 ---------------- */
struct Station { const char* name; const char* url; };
Station STATIONS[] = {
  { "中国之声", "https://ngcdn001.cnr.cn/live/zgzs/index.m3u8" },
  { "经济之声", "https://ngcdn001.cnr.cn/live/jjzs/index.m3u8" },
  { "音乐之声", "https://ngcdn001.cnr.cn/live/yyzs/index.m3u8" },
  { "中华之声", "https://ngcdn001.cnr.cn/live/zhzs/index.m3u8" },
  { "神州之声", "https://ngcdn001.cnr.cn/live/szzs/index.m3u8" },
  { "文艺之声", "https://ngcdn001.cnr.cn/live/wyzs/index.m3u8" },
};
const int ST_NUM = sizeof(STATIONS) / sizeof(STATIONS[0]);

/* ---------------- 状态 ---------------- */
int      curSt       = 0;
bool     playing     = false;
bool     mutedByUser = false;
uint8_t  vol         = 7;               /* 0..21 */
String   stLine1     = "";              /* 屏幕第二行小字 */
String   stLine2     = "";              /* 屏幕第三行小字 */
bool     wifiReady   = false;
unsigned long lastDraw   = 0;
unsigned long lastBufChk = 0;
uint32_t      lastBufPct = 0xFFFFFFFF;

/* ---------------- WiFi ----------------
   ★ CMCC-KPX5_5G 是 5GHz，ESP32-S3 只支持 2.4GHz，
     所以这里写不带 _5G 的 CMCC-KPX5（两个密码一样）。 */
struct WifiItem { const char* ssid; const char* pass; };
WifiItem WIFI_LIST[] = {
  { "CMCC-KPX5",  "YQ2SFENV" },   /* 家里 2.4G */
};
const int WIFI_NUM = sizeof(WIFI_LIST) / sizeof(WIFI_LIST[0]);
WiFiMulti wifiMulti;

Preferences prefs;

/* 配网热点 */
WebServer cfgServer(80);
DNSServer dnsServer;
bool cfgMode = false;
const char* AP_SSID = "Radio-Setup";
const char* AP_PASS = "12345678";

/* ---------------- 前置声明 ---------------- */
void drawScreen();
void startStation(int idx);
void toggleMute();
void handleKeys();

/* ==================== 按键 ==================== */
struct KeyBtn { uint8_t pin; bool stable; bool lastRead; unsigned long tMs; bool fired; };
KeyBtn bPrev = { BTN_PREV, HIGH, HIGH, 0, false };
KeyBtn bNext = { BTN_NEXT, HIGH, HIGH, 0, false };
KeyBtn bOk   = { BTN_OK,   HIGH, HIGH, 0, false };
KeyBtn bStop = { BTN_STOP, HIGH, HIGH, 0, false };

bool keyPressed(KeyBtn& kb) {
  bool rd = digitalRead(kb.pin);
  unsigned long now = millis();
  if (rd != kb.lastRead) { kb.lastRead = rd; kb.tMs = now; }
  if (now - kb.tMs < 25) return false;            /* 25ms 消抖 */
  if (rd != kb.stable) {
    kb.stable = rd;
    if (rd == LOW && !kb.fired) { kb.fired = true; return true; }
    if (rd == HIGH) kb.fired = false;
  }
  return false;
}

void handleKeys() {
  if (keyPressed(bPrev)) { Serial.println("[K1] prev"); startStation(curSt - 1); }
  if (keyPressed(bNext)) { Serial.println("[K2] next"); startStation(curSt + 1); }
  if (keyPressed(bOk))   { Serial.println("[K3] retry"); startStation(curSt); }
  if (keyPressed(bStop)) { toggleMute(); }
}


/* ==================== 中文字模（16x16，文泉驿正黑提取） ==================== */
struct ZhGlyph { const char* ch; const uint8_t bmp[32]; };
const ZhGlyph ZH_TABLE[] = {
  { "一", { 0x00,0x00, 0x00,0x00, 0x00,0x00, 0x00,0x00, 0x00,0x00, 0x00,0x00, 0x00,0x00, 0x00,0x00, 0x00,0x00, 0x7F,0xFE, 0x00,0x00, 0x00,0x00, 0x00,0x00, 0x00,0x00, 0x00,0x00, 0x00,0x00 } },
  { "上", { 0x00,0x00, 0x00,0x00, 0x01,0x00, 0x01,0x00, 0x01,0x00, 0x01,0x00, 0x01,0x00, 0x01,0x00, 0x01,0xFC, 0x01,0x00, 0x01,0x00, 0x01,0x00, 0x01,0x00, 0x01,0x00, 0x01,0x00, 0xFF,0xFE } },
  { "下", { 0x00,0x00, 0x00,0x00, 0x00,0x00, 0xFF,0xFE, 0x01,0x00, 0x01,0x00, 0x01,0x00, 0x01,0xC0, 0x01,0x60, 0x01,0x30, 0x01,0x08, 0x01,0x00, 0x01,0x00, 0x01,0x00, 0x01,0x00, 0x01,0x00 } },
  { "中", { 0x00,0x00, 0x00,0x00, 0x01,0x00, 0x01,0x00, 0x01,0x00, 0x7F,0xFC, 0x41,0x04, 0x41,0x04, 0x41,0x04, 0x41,0x04, 0x7F,0xFC, 0x41,0x04, 0x01,0x00, 0x01,0x00, 0x01,0x00, 0x01,0x00 } },
  { "之", { 0x00,0x00, 0x00,0x00, 0x00,0x00, 0x03,0x00, 0x01,0x80, 0x00,0x80, 0x00,0x00, 0x3F,0xF8, 0x00,0x10, 0x00,0x20, 0x00,0x40, 0x00,0x80, 0x03,0x00, 0x06,0x00, 0x0C,0x00, 0x3C,0x00 } },
  { "乐", { 0x00,0x00, 0x00,0x00, 0x00,0x38, 0x1F,0xE0, 0x10,0x00, 0x10,0x80, 0x10,0x80, 0x10,0x80, 0x10,0x80, 0x1F,0xFE, 0x00,0x80, 0x0C,0xB0, 0x18,0x98, 0x30,0x8C, 0x60,0x86, 0x40,0x80 } },
  { "停", { 0x00,0x00, 0x00,0x00, 0x00,0x00, 0x00,0x80, 0x10,0x80, 0x2F,0xFC, 0x20,0x00, 0x42,0x10, 0x42,0x10, 0xC0,0x00, 0xDF,0xFC, 0x58,0x04, 0x5F,0xFC, 0x40,0x40, 0x40,0x40, 0x40,0x40 } },
  { "冲", { 0x00,0x00, 0x00,0x00, 0x00,0x20, 0x40,0x20, 0x60,0x20, 0x33,0xFE, 0x02,0x22, 0x02,0x22, 0x12,0x22, 0x12,0x22, 0x03,0xFE, 0x22,0x22, 0x20,0x20, 0x20,0x20, 0x40,0x20, 0x40,0x20 } },
  { "华", { 0x00,0x00, 0x00,0x00, 0x04,0xC0, 0x04,0xC0, 0x08,0xC4, 0x18,0xD8, 0x38,0xF0, 0xEF,0xC2, 0x08,0xC2, 0x08,0x7E, 0x19,0x80, 0x01,0x80, 0x7F,0xFE, 0x01,0x80, 0x01,0x80, 0x01,0x80 } },
  { "台", { 0x00,0x00, 0x00,0x00, 0x01,0x00, 0x03,0x00, 0x06,0x00, 0x0C,0x30, 0x18,0x10, 0x30,0x78, 0x3C,0x0C, 0x00,0x04, 0x1F,0xF8, 0x10,0x08, 0x10,0x08, 0x10,0x08, 0x10,0x08, 0x1F,0xF8 } },
  { "国", { 0x00,0x00, 0x00,0x00, 0x00,0x00, 0x40,0x04, 0x40,0x04, 0x4F,0xF4, 0x41,0x04, 0x41,0x04, 0x4F,0xF4, 0x41,0x44, 0x41,0x64, 0x41,0x24, 0x5F,0xFC, 0x40,0x04, 0x40,0x04, 0x7F,0xFC } },
  { "在", { 0x00,0x00, 0x00,0x00, 0x00,0x00, 0x01,0x00, 0x03,0x00, 0x02,0x00, 0x7F,0xFE, 0x04,0x00, 0x04,0x20, 0x08,0x20, 0x18,0x20, 0x3B,0xFC, 0x68,0x20, 0x48,0x20, 0x08,0x20, 0x08,0x20 } },
  { "声", { 0x00,0x00, 0x00,0x00, 0x01,0x80, 0x01,0x80, 0x7F,0xFE, 0x01,0x80, 0x3F,0xFC, 0x00,0x00, 0x3F,0xFC, 0x30,0x84, 0x20,0x84, 0x3F,0xFC, 0x20,0x00, 0x20,0x00, 0x20,0x00, 0x60,0x00 } },
  { "失", { 0x00,0x00, 0x00,0x00, 0x01,0x80, 0x08,0x80, 0x18,0x80, 0x1F,0xFC, 0x10,0x80, 0x20,0x80, 0x20,0x80, 0x7F,0xFE, 0x01,0x80, 0x01,0x40, 0x01,0x40, 0x02,0x20, 0x04,0x30, 0x18,0x18 } },
  { "接", { 0x00,0x00, 0x00,0x00, 0x10,0x40, 0x10,0x60, 0x13,0xFE, 0x11,0x88, 0x10,0x90, 0x14,0xB2, 0x10,0x40, 0x18,0x40, 0xF7,0xFE, 0x10,0x98, 0x11,0x10, 0x10,0xE0, 0x10,0x78, 0x11,0xCC } },
  { "播", { 0x00,0x00, 0x00,0x00, 0x00,0x00, 0x10,0x1C, 0x13,0xC0, 0x13,0x48, 0x11,0x58, 0x11,0x50, 0x10,0xE0, 0x11,0xD0, 0x1B,0x4C, 0xFF,0xFE, 0x12,0x44, 0x12,0x44, 0x12,0x44, 0x12,0x44 } },
  { "放", { 0x00,0x00, 0x00,0x00, 0x00,0x00, 0x00,0x20, 0x18,0x20, 0x0C,0x60, 0x04,0x40, 0x7F,0x7E, 0x10,0xC4, 0x10,0xC4, 0x1E,0x2C, 0x12,0x28, 0x12,0x28, 0x12,0x10, 0x32,0x38, 0x22,0x6C } },
  { "文", { 0x00,0x00, 0x00,0x00, 0x02,0x00, 0x01,0x00, 0x01,0x80, 0xFF,0xFE, 0x08,0x20, 0x08,0x20, 0x04,0x60, 0x04,0x40, 0x02,0x40, 0x02,0x80, 0x01,0x80, 0x03,0x80, 0x06,0x60, 0x38,0x38 } },
  { "无", { 0x00,0x00, 0x00,0x00, 0x00,0x00, 0x3F,0xFC, 0x01,0x00, 0x01,0x00, 0x01,0x00, 0x7F,0xFE, 0x01,0x40, 0x01,0x40, 0x03,0x40, 0x02,0x40, 0x02,0x40, 0x04,0x41, 0x08,0x43, 0x30,0x42 } },
  { "暂", { 0x00,0x00, 0x00,0x00, 0x08,0x00, 0xFF,0x7C, 0x10,0x40, 0x24,0x40, 0x3F,0x48, 0x05,0x48, 0x7C,0x48, 0x04,0x88, 0x01,0x00, 0x1F,0xF8, 0x10,0x18, 0x1F,0xF8, 0x10,0x18, 0x10,0x18 } },
  { "正", { 0x00,0x00, 0x00,0x00, 0x00,0x00, 0x7F,0xFE, 0x00,0x80, 0x00,0x80, 0x00,0x80, 0x10,0x80, 0x10,0x84, 0x10,0x84, 0x10,0x80, 0x10,0x80, 0x10,0x80, 0x10,0x80, 0x10,0x80, 0xFF,0xFE } },
  { "济", { 0x00,0x00, 0x00,0x00, 0x00,0x00, 0x00,0xC0, 0x20,0x40, 0x11,0x10, 0x01,0x90, 0xC0,0xA0, 0x60,0x60, 0x10,0xF8, 0x13,0x0E, 0x0C,0x00, 0x21,0x90, 0x21,0x90, 0x21,0x10, 0x41,0x10 } },
  { "电", { 0x00,0x00, 0x00,0x00, 0x03,0x00, 0x03,0x00, 0x7F,0xF8, 0x43,0x08, 0x43,0x08, 0x43,0x08, 0x7F,0xF8, 0x43,0x08, 0x43,0x08, 0x7F,0xF8, 0x43,0x08, 0x43,0x0B, 0x03,0x02, 0x01,0x02 } },
  { "神", { 0x00,0x00, 0x00,0x00, 0x30,0x20, 0x10,0x20, 0x10,0x20, 0x7D,0xFE, 0x0D,0x22, 0x09,0x22, 0x19,0xFE, 0x19,0x22, 0x35,0x22, 0xD1,0xFE, 0x11,0x22, 0x10,0x20, 0x10,0x20, 0x10,0x20 } },
  { "线", { 0x00,0x00, 0x00,0x00, 0x10,0x50, 0x10,0x58, 0x30,0x48, 0x24,0x5C, 0x4D,0xC0, 0xF8,0x40, 0x10,0x7C, 0x33,0x40, 0x60,0x48, 0xF8,0x38, 0x00,0x30, 0x06,0x72, 0xF0,0xDA, 0x07,0x0E } },
  { "经", { 0x00,0x00, 0x00,0x00, 0x00,0x00, 0x10,0x00, 0x10,0x08, 0x20,0x10, 0x28,0x20, 0x48,0x70, 0xF9,0x8C, 0x13,0x06, 0x24,0x00, 0x61,0xFC, 0xF8,0x20, 0x00,0x20, 0x0C,0x20, 0xF0,0x20 } },
  { "继", { 0x00,0x00, 0x00,0x00, 0x10,0x10, 0x11,0x10, 0x21,0xD6, 0x29,0x54, 0x49,0x58, 0xF9,0x10, 0x11,0x30, 0x21,0x38, 0x61,0x74, 0xF9,0x56, 0x01,0x92, 0x0D,0x10, 0xF1,0x10, 0x01,0xFE } },
  { "续", { 0x00,0x00, 0x00,0x00, 0x10,0x20, 0x10,0x20, 0x21,0xFC, 0x68,0x20, 0x4B,0xFE, 0xF0,0x04, 0x10,0xB4, 0x20,0x30, 0x41,0x30, 0xF8,0xB0, 0x07,0xFE, 0x0C,0x38, 0xF0,0x64, 0x01,0xC2 } },
  { "缓", { 0x00,0x00, 0x00,0x00, 0x00,0x7C, 0x22,0x40, 0x21,0x64, 0x09,0xAC, 0x48,0x18, 0x53,0xFE, 0xB0,0x40, 0x20,0x80, 0x40,0x80, 0xE1,0xC8, 0x01,0x48, 0x0E,0x30, 0xE6,0x30, 0x0C,0xCC } },
  { "艺", { 0x00,0x00, 0x00,0x00, 0x08,0x20, 0x08,0x20, 0xFF,0xFE, 0x08,0x20, 0x00,0x00, 0x00,0x00, 0x7F,0xE0, 0x00,0xC0, 0x03,0x00, 0x06,0x00, 0x18,0x02, 0x30,0x04, 0x20,0x04, 0x1F,0xFC } },
  { "败", { 0x00,0x00, 0x00,0x00, 0x00,0x00, 0x00,0x20, 0x3E,0x20, 0x22,0x60, 0x22,0x7E, 0x2A,0x44, 0x2A,0xC4, 0x2B,0xA4, 0x2A,0x2C, 0x2A,0x28, 0x2A,0x18, 0x2A,0x10, 0x18,0x38, 0x1C,0x6C } },
  { "连", { 0x00,0x00, 0x00,0x00, 0x00,0x40, 0x60,0x40, 0x30,0x80, 0x10,0x80, 0x01,0x00, 0x03,0x20, 0xF3,0xFC, 0x30,0x20, 0x30,0x20, 0x37,0xFE, 0x30,0x20, 0x30,0x20, 0x30,0x20, 0x6E,0x00 } },
  { "音", { 0x00,0x00, 0x00,0x00, 0x00,0x00, 0x03,0x00, 0x3F,0xF8, 0x08,0x10, 0x08,0x20, 0x04,0x60, 0xFF,0xFE, 0x00,0x00, 0x00,0x00, 0x1F,0xF0, 0x10,0x10, 0x1F,0xF0, 0x10,0x10, 0x10,0x10 } },
  { "首", { 0x00,0x00, 0x00,0x00, 0x08,0x10, 0x0C,0x20, 0x06,0x60, 0xFF,0xFE, 0x01,0x00, 0x1F,0xF8, 0x10,0x08, 0x10,0x08, 0x1F,0xF8, 0x10,0x08, 0x1F,0xF8, 0x10,0x08, 0x10,0x08, 0x1F,0xF8 } },
};
const int ZH_NUM = sizeof(ZH_TABLE) / sizeof(ZH_TABLE[0]);


/* 在 (x,y) 画一个 16x16 汉字，找不到返回 false */
bool drawZhAt(const char* ch, int x, int y) {
  for (int i = 0; i < ZH_NUM; i++) {
    if (strcmp(ZH_TABLE[i].ch, ch) == 0) {
      for (int r = 0; r < 16; r++) {
        uint8_t hi = ZH_TABLE[i].bmp[r * 2];
        uint8_t lo = ZH_TABLE[i].bmp[r * 2 + 1];
        for (int c = 0; c < 8; c++) {
          if (hi & (0x80 >> c)) display.drawPixel(x + c, y + r, SSD1306_WHITE);
          if (lo & (0x80 >> c)) display.drawPixel(x + 8 + c, y + r, SSD1306_WHITE);
        }
      }
      return true;
    }
  }
  return false;
}

/* 画一串 UTF-8 汉字（只支持表里有的），返回占用宽度 */
int drawZhString(const char* s, int x, int y) {
  int cx = x;
  const unsigned char* p = (const unsigned char*)s;
  while (*p) {
    char one[5] = {0, 0, 0, 0, 0};
    int n = 1;
    if (*p < 0x80) n = 1;
    else if ((*p & 0xE0) == 0xC0) n = 2;
    else if ((*p & 0xF0) == 0xE0) n = 3;
    else if ((*p & 0xF8) == 0xF0) n = 4;
    for (int i = 0; i < n; i++) one[i] = (char)p[i];
    if (n == 1) {
      display.setTextSize(1);
      display.setTextColor(SSD1306_WHITE);
      display.setCursor(cx, y + 4);
      display.print(one);
      cx += 6;
    } else {
      drawZhAt(one, cx, y);
      cx += 16;
    }
    p += n;
    if (cx > SCR_W - 8) break;
  }
  return cx - x;
}

/* ==================== 屏幕 ==================== */
void drawWifiBar(int rssi) {
  if (!screenOK) return;
  int lv = 0;
  if (rssi > -55)      lv = 4;
  else if (rssi > -65) lv = 3;
  else if (rssi > -75) lv = 2;
  else if (rssi > -85) lv = 1;
  for (int i = 0; i < 4; i++) {
    int h = 2 + i * 2;
    int x = 2 + i * 3;
    int y = 9 - h;
    if (i < lv) display.fillRect(x, y, 2, h, SSD1306_WHITE);
    else        display.drawRect(x, y, 2, h, SSD1306_WHITE);
  }
}

void drawScreen() {
  if (!screenOK) return;
  display.clearDisplay();
  display.setTextSize(1);
  display.setTextColor(SSD1306_WHITE);

  /* 顶栏 */
  if (cfgMode) {
    display.setCursor(14, 0); display.print("SETUP MODE");
  } else if (wifiReady) {
    drawWifiBar(WiFi.RSSI());
    display.setCursor(78, 0);
    display.printf("%d/%d", curSt + 1, ST_NUM);
    display.setCursor(106, 0);
    display.printf("V%d", vol);
  } else {
    display.setCursor(14, 0); display.print("NO WIFI");
  }
  display.drawLine(0, 10, SCR_W - 1, 10, SSD1306_WHITE);

  /* 台名：16x16 点阵，居中 */
  {
    const char* nm = STATIONS[curSt].name;
    int len = 0;
    for (const unsigned char* q = (const unsigned char*)nm; *q; ) {
      if (*q < 0x80) { q += 1; len += 1; }
      else if ((*q & 0xE0) == 0xC0) { q += 2; len += 1; }
      else if ((*q & 0xF0) == 0xE0) { q += 3; len += 1; }
      else { q += 4; len += 1; }
    }
    int w = len * 16;
    int x0 = (SCR_W - w) / 2;
    if (x0 < 0) x0 = 0;
    drawZhString(nm, x0, 14);
  }

  display.setTextSize(1);
  display.setCursor(0, 34);
  if (mutedByUser)     display.print("|| PAUSED  K4=resume");
  else if (!wifiReady) display.print("connecting wifi...");
  else                 display.print(stLine1.c_str());

  display.setCursor(0, 44);
  display.print(stLine2.c_str());

  /* 缓冲条 */
  uint32_t fil = audio.inBufferFilled();
  int pct = (int)(fil * 100ULL / IN_BUF_TOTAL);
  if (pct > 100) pct = 100;
  display.drawRect(0, 54, SCR_W, 8, SSD1306_WHITE);
  if (pct > 0) display.fillRect(1, 55, (SCR_W - 2) * pct / 100, 6, SSD1306_WHITE);

  display.display();
}

/* ==================== 电台 ==================== */
void startStation(int idx) {
  if (idx < 0)       idx = ST_NUM - 1;
  if (idx >= ST_NUM) idx = 0;
  curSt = idx;
  mutedByUser = false;

  audio.stopSong();
  playing = false;
  stLine1 = "connecting...";
  stLine2 = "";
  drawScreen();

  Serial.printf("[ST] %d %s\n     %s\n", curSt, STATIONS[curSt].name, STATIONS[curSt].url);
  bool ok = audio.connecttohost(STATIONS[curSt].url);
  if (ok) {
    playing = true;
    audio.setVolume(vol);
    stLine1 = "buffering...";
  } else {
    stLine1 = "CONNECT FAIL";
    stLine2 = "K3 = retry";
  }
  drawScreen();
}

void toggleMute() {
  mutedByUser = !mutedByUser;
  audio.setVolume(mutedByUser ? 0 : vol);
  Serial.printf("[K4] %s\n", mutedByUser ? "PAUSED" : "RESUME");
  drawScreen();
}

/* ==================== 配网（家里 WiFi 连不上时） ==================== */
void buildCfgHtml() {
  String h;
  h.reserve(1400);
  h += F("<!doctype html><meta charset=utf-8><meta name=viewport content='width=device-width,initial-scale=1'>");
  h += F("<title>Radio Setup</title><body style='font:16px sans-serif;padding:18px;max-width:420px;margin:auto'>");
  h += F("<h2>收音机配网</h2>");
  h += F("<form method=POST action=/save>");
  h += F("<p>WiFi 名<br><input name=ssid style='width:100%;padding:8px' value='");
  h += WiFi.SSID();
  h += F("'></p><p>密码<br><input name=pass style='width:100%;padding:8px' value=''></p>");
  h += F("<p><button style='padding:10px 24px;font-size:16px'>保存并连接</button></p></form>");
  h += F("<p style='color:#666;font-size:13px'>保存后板子会自动重启连接。密码只存在板子里。</p>");
  h += F("<hr><p>出厂预置：<br>");
  for (int i = 0; i < WIFI_NUM; i++) h += String(i + 1) + ". " + WIFI_LIST[i].ssid + "<br>";
  h += F("</p></body>");

  cfgServer.sendHeader("Content-Type", "text/html; charset=utf-8");
  cfgServer.sendHeader("Content-Length", String(h.length()));
  cfgServer.send(200, "text/html", "");
  cfgServer.sendContent(h);
}

void runCfgPortal() {
  cfgMode = true;
  WiFi.mode(WIFI_AP_STA);
  WiFi.softAP(AP_SSID, AP_PASS);
  dnsServer.start(53, "*", WiFi.softAPIP());

  cfgServer.on("/", []() { buildCfgHtml(); });
  cfgServer.on("/save", []() {
    String s = cfgServer.arg("ssid");
    String p = cfgServer.arg("pass");
    if (s.length()) {
      prefs.begin("radio", false);
      prefs.putString("ssid", s);
      prefs.putString("pass", p);
      prefs.end();
      cfgServer.send(200, "text/html; charset=utf-8", "<meta charset=utf-8><h3>已保存，正在重启…</h3>");
      delay(1200);
      ESP.restart();
    } else {
      cfgServer.send(200, "text/html; charset=utf-8", "<meta charset=utf-8><h3>没填名字</h3>");
    }
  });
  cfgServer.onNotFound([]() { buildCfgHtml(); });
  cfgServer.begin();

  Serial.printf("[AP] %s / %s -> http://192.168.4.1\n", AP_SSID, AP_PASS);

  while (true) {
    dnsServer.processNextRequest();
    cfgServer.handleClient();
    if (screenOK) {
      display.clearDisplay();
      display.setTextColor(SSD1306_WHITE);
      display.setTextSize(1);
      display.setCursor(0, 0);  display.print("WIFI SETUP");
      display.setCursor(0, 18); display.print("1. join:");
      display.setTextSize(2);
      display.setCursor(0, 28); display.print(AP_SSID);
      display.setTextSize(1);
      display.setCursor(0, 50); display.print("2. open 192.168.4.1");
      display.display();
    }
    delay(2);
  }
}

void connectWifi() {
  WiFi.mode(WIFI_STA);
  WiFi.setSleep(false);

  prefs.begin("radio", true);
  String s = prefs.getString("ssid", "");
  String p = prefs.getString("pass", "");
  prefs.end();

  if (s.length()) {
    Serial.printf("[WIFI] nvs: %s\n", s.c_str());
    wifiMulti.addAP(s.c_str(), p.c_str());
  }
  for (int i = 0; i < WIFI_NUM; i++) wifiMulti.addAP(WIFI_LIST[i].ssid, WIFI_LIST[i].pass);

  if (screenOK) {
    display.clearDisplay();
    display.setTextColor(SSD1306_WHITE);
    display.setCursor(0, 0); display.print("WiFi...");
    display.setCursor(0, 16); display.print(WIFI_LIST[0].ssid);
    display.display();
  }

  if (wifiMulti.run(15000) == WL_CONNECTED) {
    wifiReady = true;
    IPAddress ip = WiFi.localIP();
    Serial.printf("[WIFI] ok: %s  %u.%u.%u.%u  rssi=%d\n",
                  WiFi.SSID().c_str(), ip[0], ip[1], ip[2], ip[3], WiFi.RSSI());
    return;
  }
  Serial.println("[WIFI] FAILED -> config portal");
  runCfgPortal();      /* 不返回 */
}

/* ==================== 音频回调（audioI2S 3.x 弱符号风格） ==================== */
void audio_showstreamtitle(const char* info) {
  if (info && *info) {
    stLine2 = String("Now: ") + info;
    Serial.printf("[META] %s\n", info);
  }
}
void audio_showstation(const char* info) {
  if (info && *info) Serial.printf("[STATION] %s\n", info);
}
void audio_eof_stream(const char* info) {
  Serial.println("[AUDIO] eof stream");
  playing = false;
  stLine1 = "stream ended";
  stLine2 = "K3 = reconnect";
}
void audio_info(const char* info) {
  /* 太吵，调试时再打开 */
  // Serial.printf("[A] %s\n", info);
}

/* ==================== setup / loop ==================== */
void setup() {
  Serial.begin(115200);
  delay(300);
  Serial.printf("\n=== Radio V%d ===\n", FW_VER);

  Wire.begin(PIN_SDA, PIN_SCL);
  screenOK = display.begin(SSD1306_SWITCHCAPVCC, 0x3C);
  if (screenOK) {
    display.clearDisplay();
    display.setTextColor(SSD1306_WHITE);
    display.setTextSize(2);
    display.setCursor(0, 4);  display.print("RADIO");
    display.setTextSize(1);
    display.setCursor(0, 30); display.printf("v%d booting", FW_VER);
    display.display();
  } else {
    Serial.println("[OLED] not found");
  }

  pinMode(BTN_PREV, INPUT_PULLUP);
  pinMode(BTN_NEXT, INPUT_PULLUP);
  pinMode(BTN_OK,   INPUT_PULLUP);
  pinMode(BTN_STOP, INPUT_PULLUP);

  audio.setPinout(PIN_I2S_BCLK, PIN_I2S_LRC, PIN_I2S_DOUT);
  audio.setVolume(vol);
  audio.setConnectionTimeout(6000, 6000);
  audio.setBufsize(4096, 1000 * 1024);      /* RAM 4K + PSRAM 1M */

  connectWifi();
  stLine1 = "ready";
  drawScreen();

  startStation(0);
}

void loop() {
  handleKeys();
  audio.loop();

  unsigned long now = millis();

  /* 断流自恢复：缓冲一直空着 12 秒 -> 重连 */
  if (now - lastBufChk > 2000) {
    lastBufChk = now;
    uint32_t fil = audio.inBufferFilled();
    if (fil != lastBufPct) {
      lastBufPct = fil;
      lastBufChk = now;
    } else if (playing && !mutedByUser && fil == 0) {
      static unsigned long zeroSince = 0;
      if (zeroSince == 0) zeroSince = now;
      else if (now - zeroSince > 12000) {
        zeroSince = 0;
        lastBufPct = 0xFFFFFFFF;
        Serial.println("[AUTO] no data 12s -> reconnect");
        stLine1 = "stalled, retry...";
        drawScreen();
        startStation(curSt);
      }
    }
  }

  if (now - lastDraw > 300) {
    lastDraw = now;
    if (wifiReady && WiFi.status() != WL_CONNECTED) {
      wifiReady = false;
      Serial.println("[WIFI] lost");
    } else if (!mutedByUser && audio.isRunning()) {
      uint32_t br = audio.getBitRate();
      stLine1 = String("playing ") + audio.getCodecname();
      if (br) stLine2 = String((unsigned)(br / 1000)) + " kbps";
    }
    drawScreen();
  }
}
